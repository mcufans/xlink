# Keil uVision project HID.uvproj, settings and files
target STM32F103 Flash (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hid
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\;.\lib\inc;.\SWD_JTAG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./: system_stm32l1xx.c startup_stm32l1xx_md.s
  group USB Configuration
    ./: usbcfg_STM32F10x.h
  group Source Code
    ./: usbhw_STM32F10x.c usbuser.c usbdesc.c usbcore.c demo.c
  group lib
    ./lib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group SWD_JTAG
    ./SWD_JTAG/: DAP.c SW_DP.c
